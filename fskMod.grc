options:
  parameters:
    author: guido
    generate_options: no_gui
    id: fskMod
    output_language: python
    run_options: run
    title: fskMod
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: generated at 2M/20/100 =1kbps
    file: ./inputMessage.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"fskMod: toma una senal binaria float y la modula con un FSK\"\"\"\n\n    def __init__(self, samp_rate='samp_rate', freq0=2000, freq1=6000):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='fskMod',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.samp_rate = samp_rate\n        self.freq0 = freq0\n        self.freq1 = freq1\n\n    def work(self, input_items, output_items):\n        if np.sum(input_items[0]) > 0 : # check if there is any signal\n            cont = 0\n            for i in range(len(input_items[0])):\n                if input_items[0][i] > 0:\n                    output_items[0][i] = np.exp(1j*2*np.pi*self.freq1*i*(1/self.samp_rate))\n                else:\n                    output_items[0][i] = np.exp(1j*2*np.pi*self.freq0*i*(1/self.samp_rate))\n                    cont=cont+1\n                    #if cont>2000:\n                    #    output_items[0][i]=0\n        else:\n            output_items[0][:] = 0\n        return len(output_items[0])\n\n"
    freq0: '-20000'
    freq1: '20000'
    samp_rate: 2e6/20
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf
    bb_gain0: '20'
    freq0: 450e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    bandwidth: 100e3
    center_freq: 450e6
    samp_rate: 2e6
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_repeat_0, '0', epy_block_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_uchar_to_float_0, '0']
- [epy_block_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
