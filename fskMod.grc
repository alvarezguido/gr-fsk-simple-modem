options:
  parameters:
    generate_options: qt_gui
    id: fskMod
    output_language: python
    title: fskMod
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/guido/gnuradio_proyectos/gr-fsk-tutorial/mensajeEntrada.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      #
      # SPDX-License-Identifier: GPL-3.0
      #
      # GNU Radio Python Flow Graph
      # Title: fskMod
      # GNU Radio version: 3.10.1.1

      from packaging.version import Version as StrictVersion

      if __name__ == '__main__':
          import ctypes
          import sys
          if sys.platform.startswith('linux'):
              try:
                  x11 = ctypes.cdll.LoadLibrary('libX11.so')
                  x11.XInitThreads()
              except:
                  print("Warning: failed to XInitThreads()")

      from PyQt5 import Qt
      from gnuradio import qtgui
      from gnuradio.filter import firdes
      import sip
      from gnuradio import blocks
      import pmt
      from gnuradio import gr
      from gnuradio.fft import window
      import sys
      import signal
      from argparse import ArgumentParser
      from gnuradio.eng_arg import eng_float, intx
      from gnuradio import eng_notation



      from gnuradio import qtgui

      class fskMod(gr.top_block, Qt.QWidget):

          def __init__(self):
              gr.top_block.__init__(self, "fskMod", catch_exceptions=True)
              Qt.QWidget.__init__(self)
              self.setWindowTitle("fskMod")
              qtgui.util.check_set_qss()
              try:
                  self.setWindowIcon(Qt.QIcon.fromTheme('gnuradio-grc'))
              except:
                  pass
              self.top_scroll_layout = Qt.QVBoxLayout()
              self.setLayout(self.top_scroll_layout)
              self.top_scroll = Qt.QScrollArea()
              self.top_scroll.setFrameStyle(Qt.QFrame.NoFrame)
              self.top_scroll_layout.addWidget(self.top_scroll)
              self.top_scroll.setWidgetResizable(True)
              self.top_widget = Qt.QWidget()
              self.top_scroll.setWidget(self.top_widget)
              self.top_layout = Qt.QVBoxLayout(self.top_widget)
              self.top_grid_layout = Qt.QGridLayout()
              self.top_layout.addLayout(self.top_grid_layout)

              self.settings = Qt.QSettings("GNU Radio", "fskMod")

              try:
                  if StrictVersion(Qt.qVersion()) < StrictVersion("5.0.0"):
                      self.restoreGeometry(self.settings.value("geometry").toByteArray())
                  else:
                      self.restoreGeometry(self.settings.value("geometry"))
              except:
                  pass

              ##################################################
              # Variables
              ##################################################
              self.samp_rate = samp_rate = 32000

              ##################################################
              # Blocks
              ##################################################
              self.qtgui_time_sink_x_0 = qtgui.time_sink_f(
                  1024, #size
                  samp_rate, #samp_rate
                  "", #name
                  1, #number of inputs
                  None # parent
              )
              self.qtgui_time_sink_x_0.set_update_time(0.10)
              self.qtgui_time_sink_x_0.set_y_axis(-1, 1)

              self.qtgui_time_sink_x_0.set_y_label('Amplitude', "")

              self.qtgui_time_sink_x_0.enable_tags(True)
              self.qtgui_time_sink_x_0.set_trigger_mode(qtgui.TRIG_MODE_FREE, qtgui.TRIG_SLOPE_POS, 0.0, 0, 0, "")
              self.qtgui_time_sink_x_0.enable_autoscale(False)
              self.qtgui_time_sink_x_0.enable_grid(False)
              self.qtgui_time_sink_x_0.enable_axis_labels(True)
              self.qtgui_time_sink_x_0.enable_control_panel(False)
              self.qtgui_time_sink_x_0.enable_stem_plot(False)


              labels = ['Signal 1', 'Signal 2', 'Signal 3', 'Signal 4', 'Signal 5',
                  'Signal 6', 'Signal 7', 'Signal 8', 'Signal 9', 'Signal 10']
              widths = [1, 1, 1, 1, 1,
                  1, 1, 1, 1, 1]
              colors = ['blue', 'red', 'green', 'black', 'cyan',
                  'magenta', 'yellow', 'dark red', 'dark green', 'dark blue']
              alphas = [1.0, 1.0, 1.0, 1.0, 1.0,
                  1.0, 1.0, 1.0, 1.0, 1.0]
              styles = [1, 1, 1, 1, 1,
                  1, 1, 1, 1, 1]
              markers = [-1, -1, -1, -1, -1,
                  -1, -1, -1, -1, -1]


              for i in range(1):
                  if len(labels[i]) == 0:
                      self.qtgui_time_sink_x_0.set_line_label(i, "Data {0}".format(i))
                  else:
                      self.qtgui_time_sink_x_0.set_line_label(i, labels[i])
                  self.qtgui_time_sink_x_0.set_line_width(i, widths[i])
                  self.qtgui_time_sink_x_0.set_line_color(i, colors[i])
                  self.qtgui_time_sink_x_0.set_line_style(i, styles[i])
                  self.qtgui_time_sink_x_0.set_line_marker(i, markers[i])
                  self.qtgui_time_sink_x_0.set_line_alpha(i, alphas[i])

              self._qtgui_time_sink_x_0_win = sip.wrapinstance(self.qtgui_time_sink_x_0.qwidget(), Qt.QWidget)
              self.top_layout.addWidget(self._qtgui_time_sink_x_0_win)
              self.blocks_unpack_k_bits_bb_1 = blocks.unpack_k_bits_bb(8)
              self.blocks_uchar_to_float_0 = blocks.uchar_to_float()
              self.blocks_throttle_0 = blocks.throttle(gr.sizeof_char*1, samp_rate,True)
              self.blocks_repeat_0 = blocks.repeat(gr.sizeof_float*1, 100)
              self.blocks_file_source_0 = blocks.file_source(gr.sizeof_char*1, '/home/guido/gnuradio_proyectos/gr-fsk-tutorial/mensajeEntrada.txt', True, 0, 0)
              self.blocks_file_source_0.set_begin_tag(pmt.PMT_NIL)


              ##################################################
              # Connections
              ##################################################
              self.connect((self.blocks_file_source_0, 0), (self.blocks_throttle_0, 0))
              self.connect((self.blocks_repeat_0, 0), (self.qtgui_time_sink_x_0, 0))
              self.connect((self.blocks_throttle_0, 0), (self.blocks_unpack_k_bits_bb_1, 0))
              self.connect((self.blocks_uchar_to_float_0, 0), (self.blocks_repeat_0, 0))
              self.connect((self.blocks_unpack_k_bits_bb_1, 0), (self.blocks_uchar_to_float_0, 0))


          def closeEvent(self, event):
              self.settings = Qt.QSettings("GNU Radio", "fskMod")
              self.settings.setValue("geometry", self.saveGeometry())
              self.stop()
              self.wait()

              event.accept()

          def get_samp_rate(self):
              return self.samp_rate

          def set_samp_rate(self, samp_rate):
              self.samp_rate = samp_rate
              self.blocks_throttle_0.set_sample_rate(self.samp_rate)
              self.qtgui_time_sink_x_0.set_samp_rate(self.samp_rate)




      def main(top_block_cls=fskMod, options=None):

          if StrictVersion("4.5.0") <= StrictVersion(Qt.qVersion()) < StrictVersion("5.0.0"):
              style = gr.prefs().get_string('qtgui', 'style', 'raster')
              Qt.QApplication.setGraphicsSystem(style)
          qapp = Qt.QApplication(sys.argv)

          tb = top_block_cls()

          tb.start()

          tb.show()

          def sig_handler(sig=None, frame=None):
              tb.stop()
              tb.wait()

              Qt.QApplication.quit()

          signal.signal(signal.SIGINT, sig_handler)
          signal.signal(signal.SIGTERM, sig_handler)

          timer = Qt.QTimer()
          timer.start(500)
          timer.timeout.connect(lambda: None)

          qapp.exec_()

      if __name__ == '__main__':
          main()
    example_param: '1.0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
