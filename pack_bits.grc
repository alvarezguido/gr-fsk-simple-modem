options:
  parameters:
    author: guido
    generate_options: qt_gui
    id: pack_bits
    output_language: python
    title: pack bites
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./outputPackedMessage.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./outputMessage.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', blocks_pack_k_bits_bb_0, '0']

metadata:
  file_format: 1
