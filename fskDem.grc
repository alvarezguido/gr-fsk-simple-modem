options:
  parameters:
    author: guido
    generate_options: qt_gui
    id: fskDem
    output_language: python
    title: fskDem
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '449500000'
    step: '100'
    stop: '450500000'
    value: '449962800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '-60'
    value: '-70'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 20e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/20
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-20e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/20
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 25e3
    low_cutoff_freq: 15e3
    samp_rate: samp_rate/20
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/guido/gnuradio_proyectos/gr-fsk-tutorial/bitsSalida.txt
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0+(128/2)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 256-(128/2)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.015'
    init: '0'
    low: '0.015'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.015'
    init: '0'
    low: '0.015'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/20
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/20
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: '1024'
    name: both 0&1 filtered
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: '1024'
    name: signal 1 filtered
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: '1024'
    name: signal 0 filtered
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: '1024'
    name: signal for 1
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: '1024'
    name: signal for 0
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/200
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: still 100 samples per bit
    label1: bit 1
    name: both 0&1 filtered
    size: '1024'
    srate: samp_rate/20
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/20
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_1_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_freq_sink_x_1_2, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_add_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
